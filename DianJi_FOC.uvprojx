# Keil uVision project DianJi_FOC.uvprojx, settings and files
target p13_dcurrent (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DianJi_FOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD,
  c include: .\User;.\Modules;.\BSP;.\Test;.\Lib;.\CMSIS;.\Monitor;.\Final;.\Algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c gd32f30x_it.c systick.c gd32f30x_libopt.h
  group Doc
    ./: data.txt readme03.txt readme.txt readme_02.txt
  group Modules
    ./Modules/: Motor_ctrl.c Foc.c general_def.h Angle_Feedback.c Idq_Feedback.c pid_3loops.c svpwm.c JiaoZhun.c can_up.c
  group Algorithm
    ./Algorithm/: angle.c algorithm.c
  group BSP
    ./BSP/: BSP.c timer.c adc.c spi.c encoder_spi.c ATK.c i2c.c can.c temperature_1wire.c FPC_jr.c JJKG.c gpio.c rcu.c
  group Startup
    ./Startup/: startup_gd32f30x_hd.s
  group Drivers
    ./Lib/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CMSIS
    ./CMSIS/: core_cm4.h gd32f30x.h system_gd32f30x.c
  group Monitor
    ./Monitor/: Temperature_monitor.c
